# Keil uVision project h503rb_hal.uvprojx, settings and files
target qst_sensor (6160000::V6.16::ARMCLANG)
  device: STM32H503RBTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x801FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: qst_sensor_h503rb +hex
  AfterMake: $KARM\ARMCC\bin\fromelf --bin --output="$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H503xx,QST_MAG_USE_SWJ
  c include: ../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/STM32H5xx_Nucleo;..\Drivers\SENSORS\ak0991x;..\Drivers\SENSORS\qmc6309;..\Drivers\SENSORS\qmc6308;..\Drivers\SENSORS\qmi8658;..\Drivers\SENSORS\icm4x6xx;..\Drivers\SENSORS\qmp6988;..\Drivers\SENSORS\qmp6989;..\Drivers\SENSORS\qmp6990;..\Drivers\SENSORS\mmc5603;..\Drivers\SENSORS\qmc6309v;..\Drivers\SENSORS\qma6100p;..\Drivers\SENSORS\qmc6g00x;..\Drivers\SENSORS\qma6101t;..\Drivers\SENSORS\maestro;..\Drivers\SENSORS\qmc5883l;..\Drivers\SENSORS\qmc5883p;..\Drivers\SENSORS\qmaX981;..\Drivers\BSP\hardware;..\App\wincc;..\App\myfilter;..\App\sensor;..\App\test;..\App\log;..\App\filter;..\App\imucali;..\Drivers\SYSTEM\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Doc
    ../: README.md
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_exti.c stm32h5xx_hal_cortex.c stm32h5xx_hal_i3c.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_icache.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c
  group Drivers/SENSORS
    ../Drivers/SENSORS/ak0991x/: ak0991x.c
    ../Drivers/SENSORS/qmc6309/: qmc6309.c
    ../Drivers/SENSORS/qmc6308/: qmc6308.c
    ../Drivers/SENSORS/mmc5603/: mmc5603.c
    ../Drivers/SENSORS/qmc6309v/: qmc6309v.c
    ../Drivers/SENSORS/qma6100p/: qma6100p.c
    ../Drivers/SENSORS/qma6101t/: qma6101t.c
    ../Drivers/SENSORS/qmi8658/: qmi8658.c
    ../Drivers/SENSORS/qmp6989/: qmp6989.c
    ../Drivers/SENSORS/qmc6g00x/: qmc6g00x.c
    ../Drivers/SENSORS/qmc5883l/: qmc5883l.c
    ../Drivers/SENSORS/qmaX981/: qmaX981.c
    ../Drivers/SENSORS/qmp6990/: qmp6990.c
    ../Drivers/SENSORS/icm4x6xx/: icm4x6xx.c
    ../Drivers/SENSORS/qmp6988/: qmp6988.c
    ../Drivers/SENSORS/qmc5883p/: qmc5883p.c
  group Drivers/BSP
    ../Drivers/BSP/hardware/: bsp_hardware.c bsp_i3c.c bsp_i2c.c qst_sw_i2c.c bsp_spi.c bsp_sw_spi.c bsp_flash.c
  group App
    ../App/sensor/: sensorhub.c sensorhub_algo_adp.c
    ../App/: main.c
    ../App/log/: qst_log.c qst_uart_wincc.c
    ../App/test/: magnetic_test.c
  group Algo
    ../App/filter/: MyFilter.c
    ../App/imucali/: qst_algo_imu_cali.c
  group Drivers/SYSTEM
    ../Drivers/SYSTEM/Src/: stm32h5xx_hal_msp.c stm32h5xx_it.c stm32h5xx_nucleo.c system_stm32h5xx.c
    ../Drivers/CMSIS/Device/ST/STM32H5xx/: startup_stm32h503xx.s
software components: CMSIS:CORE 4.3.0
